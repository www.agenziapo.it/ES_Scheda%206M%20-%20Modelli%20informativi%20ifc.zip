Properties of the parts of a building model (IFC4X1)

# File
Time: 2024-02-22T10:44:27
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuilding (19)
Description: Created by Civil Site Design
Name
Pavement
Topsoil
CorazzamentoConMassi
NONE
Grass
2 x TaglioPennello/RA/RS/1/Corazzamento con pietre
2 x TaglioPennello/RAT/RA/1/Corazzamento con pietre
2 x TaglioPennello/RST/RAT/1/Corazzamento con pietre
2 x TaglioPennello/C.L./RST/1/Corazzamento con pietre
2 x TaglioPennello/C.L./LST/1/Corazzamento con pietre
2 x TaglioPennello/LST/LAT/1/Corazzamento con pietre
2 x TaglioPennello/LAT/LAL/1/Corazzamento con pietre

# IfcBuildingElementProxy (19)
Description: Created by Civil Site Design
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
Pavement | Pavement
Topsoil | Topsoil
CorazzamentoConMassi | CorazzamentoConMassi
NONE | NONE
Grass | Grass
2 x TaglioPennello/RA/RS/1/Corazzamento con pietre | TaglioPennello/RA/RS/1/Corazzamento con pietre | TaglioPennello | RA | RS | 1 | Corazzamento con pietre
2 x TaglioPennello/RAT/RA/1/Corazzamento con pietre | TaglioPennello/RAT/RA/1/Corazzamento con pietre | TaglioPennello | RAT | RA | 1 | Corazzamento con pietre
2 x TaglioPennello/RST/RAT/1/Corazzamento con pietre | TaglioPennello/RST/RAT/1/Corazzamento con pietre | TaglioPennello | RST | RAT | 1 | Corazzamento con pietre
2 x TaglioPennello/C.L./RST/1/Corazzamento con pietre | TaglioPennello/C.L./RST/1/Corazzamento con pietre | TaglioPennello | C.L. | RST | 1 | Corazzamento con pietre
2 x TaglioPennello/C.L./LST/1/Corazzamento con pietre | TaglioPennello/C.L./LST/1/Corazzamento con pietre | TaglioPennello | C.L. | LST | 1 | Corazzamento con pietre
2 x TaglioPennello/LST/LAT/1/Corazzamento con pietre | TaglioPennello/LST/LAT/1/Corazzamento con pietre | TaglioPennello | LST | LAT | 1 | Corazzamento con pietre
2 x TaglioPennello/LAT/LAL/1/Corazzamento con pietre | TaglioPennello/LAT/LAL/1/Corazzamento con pietre | TaglioPennello | LAT | LAL | 1 | Corazzamento con pietre
